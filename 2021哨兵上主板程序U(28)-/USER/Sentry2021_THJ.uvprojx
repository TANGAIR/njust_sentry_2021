# Keil uVision project Sentry2021_THJ.uvprojx, settings and files
target Sentry2021_THJ (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sentry2021_THJ
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4,__FPU_USED =1,
  c include: ..\CORE;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FWLIB\inc;..\HARDWORK;..\SYSTEM;..\USER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rng.c stm32f4xx_spi.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/inc
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group SYSTEM
    ../SYSTEM/: delay.c delay.h sys.c sys.h
  group USER
    ./: main.c main.h stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h
  group BaseHardwork
    ../HARDWORK/: BEEP.c BEEP.h Laser.c Laser.h crc.c crc.h SENSOR.c SENSOR.h random.c random.h SPI.c SPI.h tim6.c tim6.h Severo.c Severo.h
  group ApplicationHardwork
    ../HARDWORK/: APP_task.c APP_task.h USART.c USART.h LED.c LED.h DR16.c DR16.h CAN.c CAN.h PID.c PID.h PTZ.c PTZ.h Referee_System.c Referee_System.h SHOOT.c SHOOT.h CHASSIS.c CHASSIS.h TIM7.c TIM7.h IMU.c IMU.h
